# Keil uVision project iSO-STM32.uvproj, settings and files
target Template (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: Template +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER
  c include: ..\..\Libraries\CMSIS;..\..\User;..\..\Libraries\FWlib\inc;..\..\User\6050\SysTick;..\..\User\6050
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group STARTUP
    ../../Libraries/CMSIS/startup/: startup_stm32f10x_hd.s
  group CMSIS
    ../../Libraries/CMSIS/: core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group FWLB
    ../../Libraries/FWlib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group USER
    ../../User/: main.c stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h cjmcu_i2c.c delay.c GPS.c bsp_usart3.c
    ../../User/6050/SysTick/: bsp_SysTick.c
    ../../User/6050/: bsp_i2c.c mpu6050.c bsp_usart1.c
